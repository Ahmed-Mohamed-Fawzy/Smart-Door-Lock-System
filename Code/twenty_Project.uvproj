# Keil uVision project twenty_Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: twenty_Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 App.c lcd.c lcd.h keypad.c keypad.h servo.c servo.h IR_Sensor.c IR_sensor.h buzzer.c buzzer.h leds_and_buttons.c leds_and_buttons.h delay.h delay.c uart.c uart.h
